require conf/include/mender-kernel-image.inc

IMAGE_INSTALL += " packagegroup-core-boot"
